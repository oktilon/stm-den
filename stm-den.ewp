# IAR project stm-den.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F40_41xxx; HSE_VALUE=8000000; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: lib\STM32F4xx\CMSIS\Include; lib\STM32F4xx\STM32F4xx_StdPeriph_Driver\inc; lib\STM32F4xx\CMSIS\Device\ST\STM32F4xx\Include; lib\STM32F4xx; app; app\board; app\lcd; app\spi; app\sys; app\uart; app\i2c; app\ds1307
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: stm-den.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    app/: main.c
    lib/STM32F4xx/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f40_41xxx.s
    lib/STM32F4xx/: stm32f4xx_conf.h
    lib/STM32F4xx/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group app/inc
    app/board/: board.h
    app/lcd/: commands.h glcdfont.h lcd.h
    app/ds1307/: ds1307.h
    app/i2c/: i2c.h
    app/spi/: spi.h
    app/sys/: sys.h
    app/uart/: uart.h
  group app/src
    app/board/: board.c
    app/ds1307/: ds1307.c
    app/i2c/: i2c.c
    app/lcd/: lcd.c
    app/spi/: spi.c
    app/sys/: sys.c
    app/uart/: uart.c
  group stm/src
    lib/STM32F4xx/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_dma.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
